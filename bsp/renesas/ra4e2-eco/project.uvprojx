# Keil uVision project project.uvprojx, settings and files
target Target_1 (6190000::V6.19::ARMCLANG)
  device: R7FA4E2B9 Renesas
  pack: Renesas.RA_DFP.5.9.0
  cpu: CPUTYPE("Cortex-M33") DSP TZ  FPU3(SFPU)  CLOCK(12000000) ELITTLE
  output: rtthread +hex
  c flags: Optim=6 OneElfS=1 v6Lang=3 v6LangP=3
  c define: __STDC_LIMIT_MACROS, RT_USING_ARMLIBC, RT_USING_LIBC, __RTTHREAD__, __CLK_TCK=RT_TICK_PER_SECOND
  c misc: -Wno-license-management -Wuninitialized -Wall -Wmissing-declarations -Wpointer-arith -Waggregate-return -Wfloat-equal
  c include: ..\..\..\components\libc\posix\io\poll;..\..\..\components\finsh;..\..\..\components\libc\posix\io\epoll;..\..\..\components\libc\compilers\common\include;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\components\libc\posix\io\eventfd;..\libraries\HAL_Drivers;..\..\..\components\drivers\include;..\..\..\include;..\..\..\components\libc\compilers\common\extension\fcntl\octal;..\..\..\libcpu\arm\common;..\..\..\components\libc\posix\ipc;board;..\..\..\components\drivers\include;board\ports;..\libraries\HAL_Drivers\config;..\..\..\components\drivers\include;..\..\..\components\drivers\phy;..\..\..\components\libc\compilers\common\extension;..\..\..\libcpu\arm\cortex-m33;..\..\..\components\drivers\smp_call;.;..\..\..\components\drivers\include
  scatter file: .\script\fsp.scat
  group Compiler
    ../../../components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    ../../../components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
  group DeviceDrivers
    ../../../components/drivers/core/: device.c
    ../../../components/drivers/i2c/: dev_i2c_bit_ops.c dev_i2c_core.c dev_i2c_dev.c
    ../../../components/drivers/ipc/: completion_comm.c completion_up.c condvar.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../../components/drivers/pin/: dev_pin.c
    ../../../components/drivers/sensor/v1/: sensor.c sensor_cmd.c
    ../../../components/drivers/serial/: dev_serial_v2.c
  group Drivers
    ../libraries/HAL_Drivers/: drv_common.c drv_gpio.c drv_usart_v2.c
  group Finsh
    ../../../components/finsh/: shell.c msh_parse.c cmd.c msh.c
  group Kernel
    ../../../src/: clock.c components.c cpu_up.c defunct.c idle.c ipc.c irq.c kservice.c mem.c object.c scheduler_comm.c scheduler_up.c thread.c timer.c
  group klibc
    ../../../src/klibc/: rt_vsscanf.c kerrno.c rt_vsnprintf_std.c kstring.c kstdio.c
  group libcpu
    ../../../libcpu/arm/common/: atomic_arm.c div0.c showmem.c
    ../../../libcpu/arm/cortex-m33/: context_rvds.S cpuport.c syscall_rvds.S trustzone.c
  group :Renesas RA Smart Configurator:Common Sources
    ./src/: hal_entry.c coredump.c demo.c fal_cfg.c
    ./src/applications/: encoder.c key.c kvdb_basic_sample.c mpu6050_demo.c SConscript sensor.c
    ./src/coredump/: SConscript
software components: Flex Software:RA Configuration 1.0.0
